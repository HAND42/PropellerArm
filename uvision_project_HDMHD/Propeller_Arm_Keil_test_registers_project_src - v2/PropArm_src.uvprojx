# Keil uVision project PropArm_src.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Timer
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: HSE_VALUE=8000000
  c include: .\00_MyCustomHAL_register_lb;.\01-Acc&Gyro_lb;.\02_STM32-LCD_fatay_lb;.\03_STM32-LCD_eng-edison_lb;.\04_LCD1602_I2C_NOHAL
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c
  group Hal_register_config
    ./00_MyCustomHAL_register_lb/: Delay.c DisplayData.c StringUtilities.c UART.c Delay.h DisplayData.h RegisterAddresses.h StringUtilities.h UART.h Led.h Led.c System_Config.c System_Config.h
  group Acc&Gyro
    ./01-Acc&Gyro_lb/: Accelerometer.c Gyro.c Accelerometer.h Gyro.h Angles_Estimation.c Angles_Estimation.h
  group LCD
    ./04_LCD1602_I2C_NOHAL/: i2c-lcd.h i2c-lcd.c
  group MotorControl
    ./: motor_pwm.c motor_pwm.h
  group I2C
    ./00_MyCustomHAL_register_lb/: I2C.c
software components: CMSIS:CORE 5.6.0, Device:STM32Cube Framework:Classic 1.8.1, Device:STM32Cube HAL:Common 1.8.1, Device:STM32Cube HAL:Cortex 1.8.1, Device:STM32Cube HAL:GPIO 1.8.1, Device:STM32Cube HAL:PWR 1.8.1, Device:STM32Cube HAL:RCC 1.8.1, Device:Startup 2.6.3
