# Keil uVision project PropellerArmROB4.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PropellerArmROB4
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=1
  c include: .\00_MyCustomHAL_register_lb;.\01-Acc&Gyro_lb;.\04_LCD1602_I2C_NOHAL
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group main
    ./: main.c
  group SystemConfig
    ./00_MyCustomHAL_register_lb/: System_Config.c RegisterAddresses.h
  group Delay
    ./00_MyCustomHAL_register_lb/: Delay.c
  group Led
    ./00_MyCustomHAL_register_lb/: Led.c
  group Theta_Acc&Gyro
    ./01-Acc&Gyro_lb/: Accelerometer.c Angles_Estimation.c Gyro.c
  group I2C
    ./00_MyCustomHAL_register_lb/: I2C.c
  group LCD
    ./04_LCD1602_I2C_NOHAL/: i2c-lcd.c
  group UART_com
    ./00_MyCustomHAL_register_lb/: UART.c StringUtilities.c DisplayData.c
  group Potentiometer
    ./: Potentiometer.c
  group Motor_control
    ./: motor_pwm.c
software components: CMSIS:CORE 6.0.0, Device:Startup 2.6.3
