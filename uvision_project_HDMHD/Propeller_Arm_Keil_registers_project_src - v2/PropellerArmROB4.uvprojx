# Keil uVision project PropellerArmROB4.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PropellerArmROB4
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=1
  c include: .\00-Clock_Systick_Delay;.\01-Acc&Gyro_Control_loop;.\02-Display_debug&QT;.\03-LCD1602_I2C_NOHAL;.\04-I2C-Slave;..\Propeller_Arm_Keil_registers_project_src - v2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group main
    ./: main.c TwinPropellerArmSTM32F411_configuration.h
  group SystemConfig
    ./00-Clock_Systick_Delay/: Delay.c Delay.h Led.c Led.h System_Config.c System_Config.h
  group Theta_Acc&Gyro_Control-loop
    ./01-Acc&Gyro_Control_loop/: Accelerometer.c Accelerometer.h Angles_Estimation.c Angles_Estimation.h Gyro.c Gyro.h motor_pwm.c motor_pwm.h Potentiometer.c Potentiometer.h
  group Display_debug&QT
    ./02-Display_debug&QT/: DisplayData.c DisplayData.h RegisterAddresses.h StringUtilities.c StringUtilities.h UART.c UART.h
  group LCD
    ./03-LCD1602_I2C_NOHAL/: i2c-lcd.c i2c-lcd.h
  group I2C_Slave_forArduinoScreenMaster
    ./04-I2C-Slave/: I2C-ST_Slave_Ard_Master.c I2C-ST_Slave_Ard_Master.h
software components: CMSIS:CORE 6.0.0, Device:Startup 2.6.3
